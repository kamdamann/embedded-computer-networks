# Keil uVision project analog_blink.uvprojx, settings and files
target analog_blink (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F746NGHx STMicroelectronics
  pack: Keil.STM32F7xx_DFP.2.13.0
  cpu: IRAM(0x20010000,0x40000) IRAM2(0x20000000,0x10000) IROM(0x08000000,0x100000) IROM2(0x00200000,0x100000) CPUTYPE("Cortex-M7") FPU3(SFPU) CLOCK(12000000) ELITTLE
  output: blinky
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F746xx
  c include: ..\inc;..\..\..\libraries\bsp\stm32f7_discovery\bsp\inc;..\..\..\libraries\bsp\stm32f7_discovery_shu_kit\inc
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT5: ROM 0x200000 size 0x100000
  memory RVCT9: RAM 0x20010000 size 0x40000
  memory RVCT10: RAM 0x20000000 size 0x10000
  group application
    ../src/: main.c
  group configuration
    ../src/: stdout_usart.c stm32f7xx_it.c
    ../inc/: stm32f7xx_it.h
  group stm32f7_discovery_bsp_shu
    ../../../libraries/bsp/stm32f7_discovery_shu_kit/src/: adc.c clock.c gpio.c
software components: CMSIS:CORE 5.4.0, Compiler:I/O:STDOUT 1.2.0, CMSIS Driver:USART 1.14.0, Device:STM32Cube Framework:Classic 1.2.8, Device:STM32Cube HAL:ADC 1.2.8, Device:STM32Cube HAL:Common 1.2.8, Device:STM32Cube HAL:Cortex 1.2.8, Device:STM32Cube HAL:DMA 1.2.8, Device:STM32Cube HAL:GPIO 1.2.8, Device:STM32Cube HAL:PWR 1.2.8, Device:STM32Cube HAL:RCC 1.2.8, Device:STM32Cube HAL:UART 1.2.8, Device:Startup 1.2.5
